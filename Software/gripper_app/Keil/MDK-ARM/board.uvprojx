# Keil uVision project board.uvprojx, settings and files
target board (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: gripper_app +hex
  AfterMake: D:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin --output board/gripper_app.bin board/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;..\Hardware\Inc;..\Application\Inc;..\..\Code\hal;..\..\Code\fml;..\..\Code\apl;..\..\Code\algo
  memory RVCT4: ROM 0x8008000 size 0x12000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Hardware/Src/: stm32g4xx_hal_msp.c stm32g4xx_it.c
    ../Application/Src/: main.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_iwdg.c
  group CMSIS
    ../Hardware/Src/: system_stm32g4xx.c
  group apl
    ../../Code/apl/: apl_main_task.c apl_servo_task.c apl_protocol.c apl_common.c
  group fml
    ../../Code/fml/: fml_modbus.c fml_motor.c fml_queue.c fml_storage.c fml_invoke_algo.c
  group hal
    ../../Code/hal/: hal_adc.c hal_dma.c hal_fdcan.c hal_flash.c hal_gpio.c hal_iwdg.c hal_tim.c hal_usart.c
  group algo
    ../../Code/algo/: algo.lib pid.c
software components: CMSIS:CORE 4.3.0
